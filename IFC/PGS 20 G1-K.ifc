Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010, QuantityTakeOffAddOnView, SpaceBoundary1stLevelAddOnView], ExchangeRequirement[Architecture], Option [ExcludedObjects: , , , , , , , , , , , , , , , , , , ,], Description [Markus]
File name: K:\PSH-BT\ZEICH\0000_PFEIFER-CAD-Bibliothek\3D-IFC_und_3D-DWG_Pfeifer\3_Verbindungstechnik\331_Fundamentanker_PGS-G_PEK_PDK\PGS_PEK\3D-DWG-Dateien\PF_331_PEK20_102015.ifc
Time: 2015-10-14T08:37:43
Author: cad
Organization: Pfeifer
Written by: EXPRESS Data Manager stand alone and remote client system - Version 5.00.0310.07.32mod Sep 15 2011
Made in: AutoCAD Architecture 2016 - Deutsch (German) Build 7.8.44.0

# IfcProject, 1
LongName: Pfeifer
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Modell

# IfcBuilding, Pfeifer
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
BaseQuantities - Height: 0 mm; NetFootprintArea: 0 m2; GrossFootprintArea: 0 m2; NetFloorArea: 0 m2; GrossFloorArea: 0 m2; GrossVolume: 0 m3
